# Keil uVision project FOC_V2_2.uvprojx, settings and files
target FOC_V2_2 (6160000::V6.16::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC_V2_2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32G431xx,__FPU_PRESENT,__FPU_USED,ARM_MATH_CM4,__ARM_FP,__CLANG_ARM
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Algorithm/inc;../Bsp/inc;../Math/inc;../Task/inc;../Drivers/CMSIS/DSP/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Algorithm
    ../Algorithm/src/: FOC.c PID.c
  group Bsp
    ../Bsp/src/: Bsp_ADC.c Bsp_CAN.c Bsp_LED.c Bsp_Motor.c
  group Task
    ../Task/src/: High_Freq_FOC_Task.c Init_Task.c Medium_Freq_Task.c Safety_Task.c
  group Math
    ../Math/src/: CRC8_CRC16.c Filter.c
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.5.0
